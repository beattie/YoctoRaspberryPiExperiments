FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SUMMARY = "Place holder to set SSID and key"
